# IAR project blink.ewp, settings and files
configuration blink (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: blink.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ./: 
  group Application/EWARM
    C:/Users/gustavo.adono/Documents/Atollic/blink/blink//EWARM/: startup_stm32f746xx.s
  group Application/User
    ./: 
    ../Src/: stm32f7xx_it.c main.c stm32f7xx_hal_msp.c
  group Drivers
    ./: 
  group Drivers/STM32F7xx_HAL_Driver
    ./: 
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_gpio.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_dma.c stm32f7xx_hal_pwr.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_rcc.c
  group Drivers/CMSIS
    ./: 
    ..//Src/: system_stm32f7xx.c
